EXTRA_IMAGE_FEATURES += "empty-root-password allow-root-login"
